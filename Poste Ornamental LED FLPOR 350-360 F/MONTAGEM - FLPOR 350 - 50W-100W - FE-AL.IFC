Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\projetos\Fortlight\Usuários - Documentos\Kevyn\ORNAMENTAIS\MONTAGEM - FLPOR 350 - 50W-100W - FE-AL.IFC
Time: 2024-09-23T14:18:51+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
