Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: C:\Users\projetos\Fortlight\Usuários - Documentos\Kevyn\ORNAMENTAIS\MONTAGEM - FLPOR 260 - 2x 50W - FE.IFC
Time: 2024-09-23T13:48:33+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
